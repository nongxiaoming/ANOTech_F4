# Keil uVision project project.uvproj, settings and files
target RTThread (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output ./rtthread.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;F:/rt-thread/components/dfs;F:/rt-thread/components/dfs/filesystems/devfs;F:/rt-thread/components/dfs/include;F:/rt-thread/components/drivers/include;F:/rt-thread/components/finsh;F:/rt-thread/components/init;F:/rt-thread/include;F:/rt-thread/libcpu/arm/common;F:/rt-thread/libcpu/arm/cortex-m4;Libraries\CMSIS\Device\ST\STM32F4xx\Include;Libraries\CMSIS\Include;Libraries\STM32F4xx_StdPeriph_Driver\inc;Libraries\STM32_USB_Device_Library\Class\cdc\inc;Libraries\STM32_USB_Device_Library\Core\inc;Libraries\STM32_USB_HOST_Library\Core\inc;Libraries\STM32_USB_OTG_Driver\inc;applications;drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32_rom.sct
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c drv_i2c.c drv_led.c drv_rtc.c drv_sd.c drv_spi.c drv_usart.c platform.c stm32f4xx_it.c
    ./drivers/: drv_ak8975.c drv_mpu6050.c drv_ms5611.c
  group STM32_StdPeriph
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Kernel
    F:/rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    F:/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    F:/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    F:/rt-thread/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    F:/rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    F:/rt-thread/components/dfs/filesystems/elmfat/option/: ccfile.c
    F:/rt-thread/components/dfs/filesystems/devfs/: devfs.c console.c
  group DeviceDrivers
    F:/rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c
    F:/rt-thread/components/drivers/rtc/: rtc.c
    F:/rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c
    F:/rt-thread/components/drivers/serial/: serial.c
    F:/rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    F:/rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group finsh
    F:/rt-thread/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Components
    F:/rt-thread/components/init/: components.c
